# Autodesk Inventor part: Fig_1732_1 1-2in
## iProperties
Created: 2011-03
Part Number: Fig_1732_1 1-2in
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
